FILESEXTRAPATHS:prepend := "${THISDIR}/imx219:"
  
SRC_URI += "file://0001-linux-imx-add-imx219.patch"
SRC_URI += "file://0002-linux-imx-remove-old-imx219-config.patch"
