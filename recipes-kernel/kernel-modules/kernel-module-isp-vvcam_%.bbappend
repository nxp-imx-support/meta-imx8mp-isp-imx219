FILESEXTRAPATHS:prepend := "${THISDIR}/imx219:"


SRC_URI += "file://0001-isp-vvcam-add-imx219.patch"  


